# Keil uVision project LCD_888_H743.uvprojx, settings and files
target LCD_888_H743 (6230000::V6.23::ARMCLANG)
  device: STM32H743BITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: LCD_888_H743 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\user\bsp\bsp_sdram;..\user\bsp\bsp_lcd;..\user\bsp\bsp_touch;..\user\application;..\user\bsp\bsp_debug;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Drivers\CMSIS\RTOS2\Include;..\user\bsp\LVGL;..\user\bsp\LVGL\examples\porting;..\user\bsp\LVGL\src;..\user\modules\UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c fmc.c i2c.c ltdc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c freertos.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group bsp/bsp_lcd
    ../user/bsp/bsp_lcd/: bsp_lcd.c bsp_lcd.h fonts.h
  group bsp/bsp_sdram
    ../user/bsp/bsp_sdram/: bsp_sdram.c bsp_sdram.h
  group bsp/bsp_touch
    ../user/bsp/bsp_touch/: bsp_touch.c bsp_touch.h bsp_touch_isr.c
  group application
    ../user/application/: app.c app.h app_demo.c app_demo.h app_selftest.c app_selftest.h app_power_test.c app_power_test.h app_tasks.c app_tasks.h
  group bsp/bsp_debug
    ../user/bsp/bsp_debug/: bsp_debug.c bsp_debug.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group bsp/LVGL_conf
    ../user/bsp/LVGL/: lv_conf.h lvgl.h
  group bsp/LVGL_porting
    ../user/bsp/LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group bsp/LVGL_src
    ../user/bsp/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../user/bsp/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../user/bsp/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../user/bsp/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../user/bsp/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../user/bsp/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../user/bsp/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../user/bsp/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../user/bsp/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../user/bsp/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../user/bsp/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../user/bsp/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../user/bsp/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../user/bsp/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../user/bsp/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../user/bsp/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../user/bsp/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../user/bsp/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../user/bsp/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../user/bsp/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../user/bsp/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../user/bsp/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../user/bsp/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../user/bsp/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../user/bsp/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../user/bsp/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../user/bsp/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../user/bsp/LVGL/src/extra/others/msg/: lv_msg.c
    ../user/bsp/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../user/bsp/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../user/bsp/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../user/bsp/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../user/bsp/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../user/bsp/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../user/bsp/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../user/bsp/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../user/bsp/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../user/bsp/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../user/bsp/LVGL/src/extra/widgets/led/: lv_led.c
    ../user/bsp/LVGL/src/extra/widgets/list/: lv_list.c
    ../user/bsp/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../user/bsp/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../user/bsp/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../user/bsp/LVGL/src/extra/widgets/span/: lv_span.c
    ../user/bsp/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../user/bsp/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../user/bsp/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../user/bsp/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../user/bsp/LVGL/src/extra/widgets/win/: lv_win.c
    ../user/bsp/LVGL/src/extra/: lv_extra.c
    ../user/bsp/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../user/bsp/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../user/bsp/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../user/bsp/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group modules/UI
    ../user/modules/UI/: AI_code.c AI_code.h alimama.c
software components: CMSIS:CORE 6.1.0
